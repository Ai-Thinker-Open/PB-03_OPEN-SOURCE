# Keil uVision project smart_nrf.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: smart_nrf +hex
  AfterMake: fromelf.exe .\Objects\smart_nrf.axf --i32combined --output .\bin\smart_nrf.hex
  AfterMake: fromelf -c -a -d -e -v -o smart_nrf.asm ./Objects/smart_nrf.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1  HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0 DEBUG_INFO=1 PHY_MODE_DEF=1 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEF_PHYPLUS_TRX_SUPPORT = 3 DEF_PHYPLUS_AUTOACK_SUPPORT = 0 DEF_PHYPLUS_NRF_SUPPORT = 0 DEF_PHYPLUS_MESH_SUPPORT = 0
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller;..\..\..\components\osal\include;..\..\..\components\common;.\source;..\..\..\components\libraries\crc16;..\..\..\components\driver\clock;..\..\..\components\arch\cm0;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\gpio;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\misc;..\..\..\components\driver\log;..\..\..\components\ble\include;..\..\..\components\aoxEst;..\..\..\components\driver\flash;..\..\..\components\libraries\fs;..\..\..\components\profiles\phy_plus_phy
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group app
    ./source/: OSAL_PhyPlusPhy.c PhyPlusPhy_main.c
    ../../../components/profiles/phy_plus_phy/: phy_plus_phy.c
  group driver
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/timer/: timer.c
    ../../../components/driver/watchdog/: watchdog.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/flash/: flash.c
  group jump
    ../../../misc/: jump_table.c
  group lib
    ../../../lib/: rf.lib
  group fs
    ../../../components/libraries/fs/: fs.c
  group ::Device
    RTE/Device/ARMCM0/: startup_ARMCM0.s system_ARMCM0.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
